# Keil uVision project shengying.uvproj, settings and files
target shengying (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: shengying +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SYS;..\USER;..\DRIVER\key;..\DRIVER\led;..\DRIVER\beep;..\DRIVER\beep
  group USER
    ./: main.c
  group DRIVER
    ../DRIVER/led/: led.c
  group SYS
    ../SYS/: public.c init.c
